# Keil uVision project STM32G474VET6.uvprojx, settings and files
target STM32G491VET6 (6210000::V6.21::ARMCLANG)
  device: STM32G491VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G491VET6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G491xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Components/Devices
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g491xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c quadspi.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_qspi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Components/Devices
    ../Components/Devices/: bsp_qspi_w25q256.c
software components: CMSIS:CORE 5.6.0
