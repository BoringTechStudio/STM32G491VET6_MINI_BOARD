# Keil uVision project FreeRTOS_SemaphoreFromISR.uvprojx, settings and files
target FreeRTOS_SemaphoreFromISR (6210000::V6.21::ARMCLANG)
  device: STM32G491VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_SemaphoreFromISR +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: G4V_MINI,USE_HAL_DRIVER,STM32G491xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/STM32G4xx_BORING;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g491xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_freertos.c stm32g4xx_hal_timebase_tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/BSP/STM32G4xx_BORING
    ../Drivers/BSP/STM32G4xx_BORING/: stm32g4xx_boring.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
