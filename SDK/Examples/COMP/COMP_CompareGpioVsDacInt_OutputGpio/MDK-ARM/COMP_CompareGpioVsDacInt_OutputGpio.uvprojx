# Keil uVision project COMP_CompareGpioVsDacInt_OutputGpio.uvprojx, settings and files
target COMP_CompareGpioVsDacInt_OutputGpio (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G491VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: COMP_CompareGpioVsDacInt_OutputGpio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: G4V_MINI,USE_HAL_DRIVER,STM32G491xx
  c include: ../Core/Inc; ..\Drivers\STM32G4xx_HAL_Driver/Inc; ..\Drivers\STM32G4xx_HAL_Driver/Inc/Legacy; ..\Drivers\CMSIS/Device/ST/STM32G4xx/Include; ..\Drivers\CMSIS/Include; ..\Drivers\BSP/STM32G4xx_BORING
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/User
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32G4xx_BORING
    ../Drivers/BSP/STM32G4xx_BORING/: STM32G4xx_BORING.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_comp.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
